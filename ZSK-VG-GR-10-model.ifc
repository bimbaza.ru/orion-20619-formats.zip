Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:11+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-VG-GR-10
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-VG-GR-10 Вазон «Сити» · чёрный гранит
In: Площадка
Description: Изделие бетонное благоустройства. Вазон «Сити» · чёрный гранит; Classification: 05.3.02.03 Вазон уличный (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-VG-GR-10; ModelReference: Вазон «Сити» · чёрный гранит; ProductionYear: 2026; ArticleNumber: ZSK-VG-GR-10
ORION_Изделие - Артикул: ZSK-VG-GR-10; Артикул прежний: SD-VG-GR-10; Наименование: Вазон «Сити» · чёрный гранит; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 530×530×1100 мм; Материал: Бетон; Цена: 72 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20619; Код КСИ: CPr>EDG010; Класс КСИ: Вазон уличный; Коды КСР: 05.3.02.03 … 59.1.15.02-0449
ADSK - ADSK_Наименование: Вазон «Сити» · чёрный гранит; ADSK_Марка: ZSK-VG-GR-10; ADSK_Код изделия: 05.3.02.03; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20619
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDG010; ZSK_Артикул_прежний: SD-VG-GR-10
Qto_ORION - Длина: 530 mm; Ширина: 530 mm; Высота: 1100 mm
